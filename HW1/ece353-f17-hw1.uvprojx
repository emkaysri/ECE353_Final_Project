# Keil uVision project ece353-f17-hw1.uvprojx, settings and files
target ECE353-Test-Code (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h hw1_ai_print_pattern.s hw1_update_lcd.s hw1.s hw1_lib.h
  group HW1_Lib
    ./: ece353_hw1.lib
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
